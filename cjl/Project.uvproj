# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil\C51\INC\Atmel
  group Source Group 1
    ./: LED.c LED.h main.c PressKey.c Tools.c Tools.h PressKey.h Proteus.c Proteus.h OneWire.c OneWire.h
